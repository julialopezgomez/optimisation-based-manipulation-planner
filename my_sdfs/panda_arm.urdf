Commit message: progress

File: my_sdfs/panda_arm.urdf (robot description, URDF)
Before this commit: robot panda, 9 links, 8 joints
Joints:
- joint panda_joint7: limit lower=-2.8973 upper=2.8973 effort=12 velocity=2.610 -> lower=-1.0 upper=1.0 effort=12 velocity=2.610
