Commit message: shorter waypoints

File: artifacts/hpp_comparison/1cap_2obs/env.urdf (robot description, URDF)
Before this commit: robot env, 1 links, 0 joints
Links:
- link env_link: geometry collision box size=3 3 0.1; collision cylinder length=0.015 radius=0.005
